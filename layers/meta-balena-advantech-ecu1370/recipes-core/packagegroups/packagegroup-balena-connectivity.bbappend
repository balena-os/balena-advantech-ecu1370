# The device has a Realtek 8168 that requires it's firmware.
CONNECTIVITY_FIRMWARES:append = " \
  linux-firmware-rtl8168 \
"
